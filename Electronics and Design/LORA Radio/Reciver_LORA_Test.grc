options:
  parameters:
    generate_options: qt_gui
    id: Reciver_LORA_Test
    output_language: python
    title: Reciver_LORA_Test
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: '915300000'
  states: {}
- name: IP
  id: variable
  parameters:
    value: '"usb:1.16.5"'
  states: {}
- name: Spreading_Factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: btn_trigger_ESTOP
  id: variable_qtgui_push_button
  parameters:
    label: ESTOP
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: btn_trigger_start
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: START
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: bufferSize
  id: variable
  parameters:
    value: '131072'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("                     STARTMAIN")
    period: '500'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("ESTOP")
    period: '1000'
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not btn_trigger_start
    type: complex
  states: {}
- name: blocks_mute_xx_0_0
  id: blocks_mute_xx
  parameters:
    mute: not btn_trigger_ESTOP
    type: complex
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20'
    bandwidth: '20000000'
    buffer_size: bufferSize
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Frequency
    samplerate: sample_rate
    type: fc32
    uri: IP
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: bufferSize
    filter_source: '''Auto'''
    frequency: Frequency
    gain1: '''slow_attack'''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: IP
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: sample_rate
    sf: Spreading_Factor
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    samp_rate: sample_rate
    sf: Spreading_Factor
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '500000'
    sf: Spreading_Factor
    sync_word: '[0x12]'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '1000000'
    fc: Frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: import sys; sys.path.append('/usr/lib/python3.13/site-packages')
    section: Main Python Init
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [blocks_message_strobe_0_0, strobe, lora_tx_0_0, in]
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', lora_rx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', blocks_mute_xx_0, '0']
- [lora_tx_0_0, '0', blocks_mute_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
