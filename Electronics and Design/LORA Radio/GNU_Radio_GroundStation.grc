options:
  parameters:
    generate_options: qt_gui
    id: GNU_Radio_GroundStation
    max_nouts: '32768'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1_000_000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("          Start")
    period: '1000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '915_000_000'
    samplerate: samp_rate
    type: fc32
    uri: usb:1.12.5
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '915_000_000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb:1.12.5
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: '1'
    label: Message
    type: string
    value: Start
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [iio_pluto_source_0, '0', lora_rx_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, log]
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', iio_pluto_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, pdu_pdu_filter_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
