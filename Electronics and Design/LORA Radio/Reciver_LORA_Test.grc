options:
  parameters:
    generate_options: qt_gui
    id: Reciver_LORA_Test
    output_language: python
    title: Reciver_LORA_Test
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '915300000'
    gain1: '''slow_attack'''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1000000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: 915.3e6
    channel_list: '[915.3e6]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 1e6
    sf: '7'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '1000000'
    fc: '915300000'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', lora_lora_receiver_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_lora_receiver_0, frames, blocks_message_debug_0, log]
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
