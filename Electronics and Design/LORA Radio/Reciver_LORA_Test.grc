options:
  parameters:
    generate_options: qt_gui
    id: Reciver_LORA_Test
    output_language: python
    title: Reciver_LORA_Test
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: '915300000'
  states: {}
- name: Pluto_IP
  id: variable
  parameters:
    value: '"192.168.2.1"'
  states: {}
- name: Spreading_Factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("START_MISSION")
    period: '1000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Frequency
    samplerate: sample_rate
    type: fc32
    uri: Pluto_IP
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: Frequency
    gain1: '''slow_attack'''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: Pluto_IP
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: Frequency
    channel_list: '[Frequency]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: sample_rate
    sf: Spreading_Factor
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '1000000'
    fc: Frequency
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', lora_lora_receiver_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_lora_receiver_0, frames, blocks_message_debug_0, log]
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
